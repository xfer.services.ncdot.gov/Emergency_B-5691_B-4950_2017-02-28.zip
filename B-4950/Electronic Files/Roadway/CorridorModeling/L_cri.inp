XSECTION 

PROPOSED XS

/* >>> For english, reset the tolerance to 0.10 <<< */
Tolerance = 0.10

PATTERN DGN = R:\Roadway\XSC\B4950_Rdy_pat.dgn
PATTERN SET
JOB NUMBER = rdy
BASELINE = L
HORIZ SCALE = 10
VERT SCALE = 10
TYPE = LINE,LINE_STRING
LVNAME = Pattern 1

DEFINE "TM01 CONFIG" 0

DEFINE "SH01 WIDTH CUT" 6
DEFINE "SH01 WIDTH FILL" 6
DEFINE "SH01 SLOPE" 0.08
DEFINE "SH01 SECTION" 1

DEFINE "LD01 DITCH WIDTH" 8
DEFINE "LD01 DITCH SLOPE" 4
DEFINE "LD01 FIX CUT SLOPE" 2

DEFINE "LD01 USE GUARDRAIL LINE OFFSET" 1 
DEFINE "LD01 FIX FILL SLOPE BY GUARDRAIL LINE" 2
DEFINE "LD01 WIDEN BY GUARDRAIL LINE" 1 
DEFINE "LD01 WIDENFORGUARDRAIL LINE" 1 

DEFINE_DGN "GUARDRAIL LINE"\
   DGN = R:\Roadway\XSC\B4950_Rdy_shp.dgn
   LVNAME = Prop Guardrail

DEFINE "PAVEMENT DEPTH" 6.5

/* >>> For english, change the extension from .met to .eng <<< */
include L:\standard.eng

CRITERIA FOR SHAPE CLUSTER
SHAPE CLUSTER BASELINE = L
SHAPE CLUSTER PROFILE = L
SHAPE CLUSTER TIE = 0

SIDE SLOPE LT
   include L:\tmplt01.cri
   include L:\shld01.cri
   include L:\ldss01.cri

SIDE SLOPE RT
   include L:\tmplt01.cri   
   include L:\shld01.cri
   include L:\ldss01.cri

SHAPE DGN = R:\Roadway\XSC\B4950_Rdy_shp.dgn
SHAPE SET
TYPE = CMP_SHAPE
LVNAME = Prop Geopak Pavement Shape Dependent
LVNAME = Prop Geopak Pavement Shape Independent

XS DGN = R:\Roadway\XSC\B4950_rdy_XSC.dgn
EXISTING GROUND LINE
TYPE = LINE,LINE_STRING
LVNAME = Exist XS Ground Line

PLOT PARAMETERS
LINE
LVNAME= Prop XS Dump Level

PAVEMENT THICKNESS = 0.0
DO NOT FILL GAPS BETWEEN CLUSTERS
WRITE XS INTO DGN = R:\Roadway\XSC\B4950_rdy_XSC.dgn
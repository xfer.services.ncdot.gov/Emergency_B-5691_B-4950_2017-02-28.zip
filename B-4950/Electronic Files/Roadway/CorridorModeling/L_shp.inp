auto shape
job number = RDY
 
   auto shape set
      shape cluster baseline   = L
      shape cluster profile    = L
      shape cluster tie        = 0.0000
      dependent shape
      chain  /  offset
         L          -10.0000
         L           0.0000
      filler line station / slope
         11+00.00      -2.00
         21+40.00      -2.00
        
   auto shape set
      shape cluster baseline   = L
      shape cluster profile    = L
      shape cluster tie        = 0.0000
      dependent shape
      chain  /  offset
         L          0.0000
         L          10.0000
      filler line station / slope
         11+00.00      -2.00
         21+40.00      -2.00
       
Write shapes into dgn = R:\Roadway\XSC\B4950_Rdy_shp.dgn
